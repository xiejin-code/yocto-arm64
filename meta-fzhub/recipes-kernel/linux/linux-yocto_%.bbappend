COMPATIBLE_MACHINE:fzhub = "fzhub"
